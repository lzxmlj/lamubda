# Keil uVision project sawmachine.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F373RB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sdadc +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32373C_EVAL, STM32F37X
  c include: ..\user;..\stm32f3;..\lib\inc;..\lib\src;..\drive;.\APP;.\CCP;.\io_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./: startup_stm32f37x.s
    ../stm32f3/: system_stm32f37x.c
  group drive
    ../drive/: uart.c sdadc.c systick.c
    ./: can.c
  group user
    ./: main.c adc.c
    ./APP/: APP_can.c can_xfer.c dd_can.c initialize.c interrupt.c
    ./CCP/: ccp2conf.c ccp2daq.c ccp2main.c ccp2mem.c ccp2mode.c ccp2nvmd.c ccp2session_nvm.c
    ./io_config/: io_can_config.c
  group lib
    ../lib/src/: stm32f37x_usart.c stm32f37x_gpio.c stm32f37x_sdadc.c stm32f37x_exti.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_pwr.c stm32f37x_can.c stm32f37x_adc.c stm32f37x_dma.c stm32f37x_flash.c stm32f37x_tim.c stm32f37x_dac.c stm32f37x_spi.c
    ../stm32f3/: stm32f37x_it.c
