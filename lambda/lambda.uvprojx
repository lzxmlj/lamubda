# Keil uVision project lambda.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F373VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Show_demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drive;.\lib\inc;.\stm32f3;.\user;.\user\APP;.\user\CCP;.\user\io_config;.\Utilities
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./drive/: led.c sd.c sdadc.c systick.c uart.c
    ./lib/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
    ./stm32f3/: stm32f37x_it.c system_stm32f37x.c
    ./user/: adc.c can.c main.c startup_stm32f37x.s
    ./user/CCP/: ccp2conf.c ccp2daq.c ccp2main.c ccp2mem.c ccp2mode.c ccp2nvmd.c ccp2session_nvm.c
    ./user/APP/: APP_can.c can_xfer.c dd_can.c initialize.c interrupt.c
    ./user/io_config/: io_can_config.c
